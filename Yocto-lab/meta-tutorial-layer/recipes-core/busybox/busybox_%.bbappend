SRC_URI += "file://fragment.cfg;subdir=busybox-1.32.0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

