SRC_URI += "file://001-add-i2c1-device-in-dts.patch;subdir=git"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

