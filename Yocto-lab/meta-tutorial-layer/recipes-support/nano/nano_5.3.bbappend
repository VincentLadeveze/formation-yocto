SRC_URI += "file://001-modified-welcome-message.patch;subdir=nano-5.3"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

